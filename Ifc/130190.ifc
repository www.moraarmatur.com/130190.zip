Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X_PLATFORM
File name: Ostnor
Time: 2008-09-22T09:45:18
Written by: Revit Architecture 2009 - 1.0
Made in: 20080321_1900

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_Identity Data - Name: Level 1
PSet_Revit_Constraints - Elevation: 0 mm
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm

# IfcBuildingElementProxy: Mora Rexx 130190, 130190:Mora Rexx 130190:Mora Rexx 130190:119234
In: Level 1
PSet_Revit_Dimensions - Mounting Height: 1950 mm
PSet_Revit_Constraints - Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
PSet_Revit_Identity Data - Mark: 20
PSet_Revit_Type_Identity Data - VVS: 73 7803.504; URL: www.moraarmatur.com; RSK: 893 21 77; NRF: 429 45 85; Model: 130190; Manufacturer: Mora Armatur AB; LVI: 6569455; Family: Mora Rexx; Description: Mora Rexx S5 Showerset Chrome, also available as Chrome/Black and Stainless look
